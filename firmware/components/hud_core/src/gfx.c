#include "gfx.h"

#include <stdlib.h>
#include <string.h>

/* Classic 5x7 font, ASCII 0x20..0x7F. One byte per column, LSB = top row. */
static const uint8_t FONT5X7[96][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5F, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00},
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, {0x24, 0x2A, 0x7F, 0x2A, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x55, 0x22, 0x50}, {0x00, 0x05, 0x03, 0x00, 0x00}, {0x00, 0x1C, 0x22, 0x41, 0x00},
    {0x00, 0x41, 0x22, 0x1C, 0x00}, {0x14, 0x08, 0x3E, 0x08, 0x14}, {0x08, 0x08, 0x3E, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x60, 0x60, 0x00, 0x00},
    {0x20, 0x10, 0x08, 0x04, 0x02}, /* / */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00}, {0x42, 0x61, 0x51, 0x49, 0x46},
    {0x21, 0x41, 0x45, 0x4B, 0x31}, {0x18, 0x14, 0x12, 0x7F, 0x10}, {0x27, 0x45, 0x45, 0x45, 0x39},
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03}, {0x36, 0x49, 0x49, 0x49, 0x36},
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */
    {0x00, 0x36, 0x36, 0x00, 0x00}, {0x00, 0x56, 0x36, 0x00, 0x00}, {0x08, 0x14, 0x22, 0x41, 0x00},
    {0x14, 0x14, 0x14, 0x14, 0x14}, {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x51, 0x09, 0x06},
    {0x32, 0x49, 0x79, 0x41, 0x3E}, /* @ */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, {0x7F, 0x49, 0x49, 0x49, 0x36}, {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01},
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, {0x7F, 0x08, 0x08, 0x08, 0x7F}, {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01}, {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F}, {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06}, {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7F, 0x01, 0x01}, {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, {0x3F, 0x40, 0x38, 0x40, 0x3F}, {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */
    {0x00, 0x7F, 0x41, 0x41, 0x00}, {0x02, 0x04, 0x08, 0x10, 0x20}, {0x00, 0x41, 0x41, 0x7F, 0x00},
    {0x04, 0x02, 0x01, 0x02, 0x04}, {0x40, 0x40, 0x40, 0x40, 0x40}, {0x00, 0x01, 0x02, 0x04, 0x00},
    {0x20, 0x54, 0x54, 0x54, 0x78}, {0x7F, 0x48, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x20},
    {0x38, 0x44, 0x44, 0x48, 0x7F}, {0x38, 0x54, 0x54, 0x54, 0x18}, {0x08, 0x7E, 0x09, 0x01, 0x02},
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, {0x7F, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7D, 0x40, 0x00},
    {0x20, 0x40, 0x44, 0x3D, 0x00}, {0x7F, 0x10, 0x28, 0x44, 0x00}, {0x00, 0x41, 0x7F, 0x40, 0x00},
    {0x7C, 0x04, 0x18, 0x04, 0x78}, {0x7C, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38},
    {0x7C, 0x14, 0x14, 0x14, 0x08}, {0x08, 0x14, 0x14, 0x18, 0x7C}, {0x7C, 0x08, 0x04, 0x04, 0x08},
    {0x48, 0x54, 0x54, 0x54, 0x20}, {0x04, 0x3F, 0x44, 0x40, 0x20}, {0x3C, 0x40, 0x40, 0x20, 0x7C},
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, {0x3C, 0x40, 0x30, 0x40, 0x3C}, {0x44, 0x28, 0x10, 0x28, 0x44},
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, {0x44, 0x64, 0x54, 0x4C, 0x44}, /* z */
    {0x00, 0x08, 0x36, 0x41, 0x00}, {0x00, 0x00, 0x7F, 0x00, 0x00}, {0x00, 0x41, 0x36, 0x08, 0x00},
    {0x08, 0x04, 0x08, 0x10, 0x08}, /* ~ */
    {0x00, 0x06, 0x09, 0x09, 0x06}, /* 0x7F -> degree sign */
};

void gfx_clear(gfx_t *g, uint16_t c)
{
    if (c == 0) {
        memset(g->px, 0, (size_t)g->w * g->h * 2);
        return;
    }
    for (int i = 0; i < g->w * g->h; i++) g->px[i] = c;
}

void gfx_pixel(gfx_t *g, int x, int y, uint16_t c)
{
    if ((unsigned)x < (unsigned)g->w && (unsigned)y < (unsigned)g->h) {
        g->px[y * g->w + x] = c;
    }
}

void gfx_hline(gfx_t *g, int x, int y, int w, uint16_t c)
{
    if ((unsigned)y >= (unsigned)g->h) return;
    if (x < 0) { w += x; x = 0; }
    if (x + w > g->w) w = g->w - x;
    for (int i = 0; i < w; i++) g->px[y * g->w + x + i] = c;
}

void gfx_vline(gfx_t *g, int x, int y, int h, uint16_t c)
{
    if ((unsigned)x >= (unsigned)g->w) return;
    if (y < 0) { h += y; y = 0; }
    if (y + h > g->h) h = g->h - y;
    for (int i = 0; i < h; i++) g->px[(y + i) * g->w + x] = c;
}

void gfx_line(gfx_t *g, int x0, int y0, int x1, int y1, uint16_t c)
{
    const int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
    const int dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
    int err = dx + dy;
    for (int guard = 0; guard < 2048; guard++) {
        gfx_pixel(g, x0, y0, c);
        if (x0 == x1 && y0 == y1) break;
        const int e2 = 2 * err;
        if (e2 >= dy) { err += dy; x0 += sx; }
        if (e2 <= dx) { err += dx; y0 += sy; }
    }
}

void gfx_rect(gfx_t *g, int x, int y, int w, int h, uint16_t c)
{
    gfx_hline(g, x, y, w, c);
    gfx_hline(g, x, y + h - 1, w, c);
    gfx_vline(g, x, y, h, c);
    gfx_vline(g, x + w - 1, y, h, c);
}

void gfx_fill_rect(gfx_t *g, int x, int y, int w, int h, uint16_t c)
{
    for (int j = 0; j < h; j++) gfx_hline(g, x, y + j, w, c);
}

void gfx_circle(gfx_t *g, int cx, int cy, int r, uint16_t c)
{
    int x = r, y = 0, err = 1 - r;
    while (x >= y) {
        gfx_pixel(g, cx + x, cy + y, c); gfx_pixel(g, cx + y, cy + x, c);
        gfx_pixel(g, cx - y, cy + x, c); gfx_pixel(g, cx - x, cy + y, c);
        gfx_pixel(g, cx - x, cy - y, c); gfx_pixel(g, cx - y, cy - x, c);
        gfx_pixel(g, cx + y, cy - x, c); gfx_pixel(g, cx + x, cy - y, c);
        y++;
        if (err < 0) {
            err += 2 * y + 1;
        } else {
            x--;
            err += 2 * (y - x) + 1;
        }
    }
}

void gfx_fill_circle(gfx_t *g, int cx, int cy, int r, uint16_t c)
{
    for (int dy = -r; dy <= r; dy++) {
        int dx = 0;
        while ((dx + 1) * (dx + 1) + dy * dy <= r * r) dx++;
        gfx_hline(g, cx - dx, cy + dy, 2 * dx + 1, c);
    }
}

void gfx_diamond(gfx_t *g, int cx, int cy, int r, uint16_t c)
{
    gfx_line(g, cx, cy - r, cx + r, cy, c);
    gfx_line(g, cx + r, cy, cx, cy + r, c);
    gfx_line(g, cx, cy + r, cx - r, cy, c);
    gfx_line(g, cx - r, cy, cx, cy - r, c);
}

void gfx_triangle(gfx_t *g, int x0, int y0, int x1, int y1, int x2, int y2, uint16_t c)
{
    gfx_line(g, x0, y0, x1, y1, c);
    gfx_line(g, x1, y1, x2, y2, c);
    gfx_line(g, x2, y2, x0, y0, c);
}

void gfx_text(gfx_t *g, int x, int y, const char *s, uint16_t c, int scale)
{
    if (scale < 1) scale = 1;
    for (; *s; s++) {
        unsigned ch = (unsigned char)*s;
        if (ch < 0x20 || ch > 0x7F) ch = '?';
        const uint8_t *glyph = FONT5X7[ch - 0x20];
        for (int col = 0; col < 5; col++) {
            uint8_t bits = glyph[col];
            for (int row = 0; row < 7; row++, bits >>= 1) {
                if (bits & 1) {
                    if (scale == 1) {
                        gfx_pixel(g, x + col, y + row, c);
                    } else {
                        gfx_fill_rect(g, x + col * scale, y + row * scale, scale, scale, c);
                    }
                }
            }
        }
        x += 6 * scale;
    }
}

int gfx_text_width(const char *s, int scale)
{
    const int n = (int)strlen(s);
    return n ? (n * 6 - 1) * (scale < 1 ? 1 : scale) : 0;
}

void gfx_text_c(gfx_t *g, int x, int y, const char *s, uint16_t c, int scale)
{
    gfx_text(g, x - gfx_text_width(s, scale) / 2, y, s, c, scale);
}
